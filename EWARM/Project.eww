<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Secondary_Controler.ewp</path>
  </project>
  <batchBuild />
</workspace>
